<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>tutorial_qpsk_demod_py_cb</key>
<param><key>id</key><value>tutorial_qpsk_demod_py_cb_1</value></param>
<param><key>gray_code</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>4</value></param>
</block>
<block>
<key>tutorial_qpsk_demod_py_cb</key>
<param><key>id</key><value>tutorial_qpsk_demod_py_cb_1_0</value></param>
<param><key>gray_code</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>tutorial_cpp_my_qpsk_demod_cb</key>
<param><key>id</key><value>tutorial_cpp_my_qpsk_demod_cb_0</value></param>
<param><key>gray_code</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_1</value></param>
<param><key>scale</key><value>4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>tutorial_qpsk_demod_py_cb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tutorial_qpsk_demod_py_cb_1</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tutorial_qpsk_demod_py_cb_1_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>tutorial_qpsk_demod_py_cb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>tutorial_cpp_my_qpsk_demod_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tutorial_cpp_my_qpsk_demod_cb_0</source_block_id><sink_block_id>blocks_char_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
